# Repository RoboMaster-Club/Electrical-System

File README.md:

# Robomaster Electrical System Repo
Welcome to Purdue Robomaster Club's Electrical System Repository Created by Chengming Zhang. This repository contain everything from PCB design, Design Notebook (In sub-folder's ReadMe.md), and softwares. 

If you are not familier with Robomaster, or Purdue's Robomaster Team, please refer to [Our Website](https://www.PurdueRM.com "Purdue Robomaster") or check out this video covered by **The Verge**.

<br><br>

<iframe width="560" height="315" src="https://www.youtube.com/embed/ECr4zgK6cPA" frameborder="0" allow="accelerometer; autoplay; encrypted-media; gyroscope; picture-in-picture" allowfullscreen></iframe>

## Team Structure

**Electrical Team Lead**: Chengming Zhang ` @cmz97` 

**Active Member:**

Henry Silva ` @Lazloian` 

Dansen Wang ` @cmz97` 

MingCheng Li ` @blaticslm` 

Ben Mirvish ` @bmivish` 

## Project Structure

📣**For detail design notebook, pls visit the coresponding directory**📣

▶️ Work in-Progress

🔜 Future Project

🉑 Completed Project

🔂 New Iteration

‼️ Need Documentation

⚠️ Ship Blocker

🚮 Abanded Project

<br><br>

The image bellow is our latest **Electrical System Diagram** which lays out all the connection between our subsystems.

## Power Electronics

### Super Capacitor Bank ‼️ ▶️ ⚠️

 `Made by @bmirvish @blaticslm`

Due to the competition rule, the robot chassis, which consists of four DJI 3508 geared brushless motor, can not draw more than 240W of power at any given time. To overcome this limitation, we designed our custom made supercapacitor bank as a buffer that provides instantaneous power to our robot on demand. **This Capacitor Bank only consist of voltage banlancing circuit, ADC, and the Super Capacitor Unit.** Since this is a passive electrical unit, there is no firmware.

> Plan for your PCB, Electrical Parameter and Mechinical Parameters like dimentions in your own folder‼️

> * PCB Design  @#todo‼️
> * CAD Design Enclosure @#google drive link‼️

<br>

### Super Capacitor Charger (STM32) ‼️ 🔜 ⚠️ 🔂

`Made by @cmz97`

Since Capacitor is a short circuit when not charged, we need to design a consitance current charger to avoid damage of the battery and capacitor. Chengming Selected to use a H bridge Configuration to create a custon buck convertor using STM32F334. Currently, the Super Capacitor Charger can takes any voltage between 5v - 50v and convert it to 1v - 40v. The maxium output current is 10A. The PCB has a dimension of 2.599 in x 2.487 in and four layer. 

<br>

PCB Design @[SuperCapacitor-v2.0](https://github.com/RoboMaster-Club/Electrical-System/tree/master/SuperCapacitor-v2.0)

Firmware @[SuperCapacitor-v2.0](https://github.com/RoboMaster-Club/Electrical-System/tree/master/SuperCapacitor-v2.0)

<br>

### Power Distribution Boards 🉑

Power Distribution Board is used to distribute electrical current in different voltage across the robot. Currently the Robot takes the following voltage level. 

> **24 Volt** for Robot controller, Any motor

> **12 Volt** for Jetson TX 2, Transparent OLED

> **5 Volt** for Gimbal Electrical Controller Board (ATMEGA), Electrical System Controller(ESP32)

> **3.3 Volt** for all the embedded chip, STM32F4, ESP32, ATMEGA

> **1.5 Volt** for Ammo remaining detection circuit

For a more accurate and compelete report on voltage and current usage of our robot, pls refer to [Power Distribution Board Design Log](https://github.com/RoboMaster-Club/Electrical-System/blob/master/Power-Distribution-Board-V3.0/README.md)

The newst power distribution board is divided into three seperated board:

<br>

### Chassis Power Distribution Board

`Made by @cmz97`

This board provides all the power delivery on the robot chassis, which consist of four DJI M3508 Motor. It also has a 3.3v relay on board that selection output from either the super capacitor bank or the battery directorly. This switching action can be controlled by software via a logic high, which is passed through a opto-isolator  for signal isolation. In case of emergency, such as super capacitor failure, one can flip a by-pass switch that disable all software input, and force the circuit to take battery input only. 

<br><br>

The software switch is controlled by the Electrical System Controller (STM32/ESP32) that switch the output dynamically according to the current power usage. In seniorio such as low votage on super capacitor, Electrical System Controller can select battery input to avoid damage to the supercapacitor, and left it for charging. 

[Chassis Power Distribution Board  Repository for Detail Info](https://github.com/RoboMaster-Club/Electrical-System/tree/master/Power-Distribution-Board-V3.0/Chassis%20Power%20Distribution%20Board)‼️

<br>

### Slip-Ring Power Distribution Board

`Made by @cmz97`

This board provides power to the Pitch Motor for the gimbal system, as well as power for Electrical System Controller. The board also provides pre-organization of the wires that go up through the slip-ring. Slipring is used in the robot due to mechanical constraints, where the robot's gimbal needs to rotate continuously. Since there are only 24 wires passess through the slipring used in our standard robot, with each of the wire capable of carring 2A of maxium continouse current, proper signal allocation need to be conducted. <br><br>

We concluded the following wiring asssignment:

| Signal Name     | 8A Power | 8A GND | 4A Power | 4A GND | Motor CAN H | Motor CAN L | REF_TX | REF_RX | GPIO | ESP32_TX | Referee System | Ammo Boost |
| --------------- | -------- | ------ | -------- | ------ | ----------- | ----------- | ------ | ------ | ---- | -------- | -------------- | ---------- |
| # of Wire       | 4        | 4      | 2        | 2      | 1           | 1           | 1      | 1      | 1    | 1        | 4              | 2          |
| Max Current (A) | 8        | 8      | 4        | 4      | 2           | 2           | 2      | 2      | 2    | 2        | 2              | 2          |

<br><br>

[SlipRing Distribution Board Repository for Detail Info](https://github.com/RoboMaster-Club/Electrical-System/tree/master/Power-Distribution-Board-V3.0/SlipRing%20Distribution%20Board)

<br>

### Gimbal Power Distribution Board

`Made by @cmz97`

This board provides power to the STM32 Robot controller, JetsonTX2, Yall Motor, Flywheel, ammo motor, as well as the Gimbal Electrical System Controller. On board this board, there are two MP1584EN buck convertor that converts 24v from the battery to 12v for Tx2 and 5v for the Gimbal Electrical System Controller.

[Robomater Gimbal Power Distribution Board Repository for Detail Info](https://github.com/RoboMaster-Club/Electrical-System/tree/master/Power-Distribution-Board-V3.0/Robomater%20Gimbal%20Power%20Distribution%20Board)

<br>
<br>

## Embedded Systems

### Electrical System Controller (STM32) ‼️🔂

* PCB Design `Made by @cmz97`

* Firmware `Made by @William-An`

<br>

### Remote Electrical System Monitor ‼️🔜

`Made by @cmz97`

<br>

### Gimbal Electrical System Controller (ATMEGA) 🔂 ▶️‼️

 `Made by @Lazloian`

  System Controller uses a transparent OLED in front of the driver's camera to display information to the driver. Board recieves info from ammo detector and tof sensors

  HUD Info

  * Lines on the sides indicate walls that are close to the robot

  * Cross hairs in the center of the screen indicate low ammo in the hopper

<br>

### Low Ammo Detection ‼️🔜

 `Made by @Lazloian`

<br>

### Robot Controller (STM32) ‼️

<br>

### Computer Vision System (Jetson TX 2)‼️

<br>

## EAGLE design Robomaster-I2C-Multiplexer-Board-V1.0/RMMB.brd

Parts:
C1: 10uF; C0603
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: LEDCHIP-LED0603; CHIP-LED0603
R1, R2, R3, R4: 10k; RESPACK_4X0603
R5: 10k; R0603
R14, R15: 2.2k; RESPACK_4X0603
S0, S1, S2, S3, S4, S5, S6, S7, S8: SM04B-GHS-TB(LF)(SN)-; JST_SM04B-GHS-TB(LF)(SN)-
U1: TCA9548APWR; SOP65P640X120-24N
U$1, U$2, U$31: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
3.3V: C1.1, R1.5 (2), R1.6 (2), R1.7 (2), R1.8 (2), R2.5 (2), R2.6 (2), R2.7 (2), R2.8 (2), R3.5 (2), R3.6 (2), R3.7 (2), R3.8 (2), R4.5 (2), R4.6 (2), R4.7 (2), R4.8 (2), R5.2, S0.1, S1.1, S2.1, S3.1, S4.1, S5.1, S6.1, S7.1, S8.1, U1.24 (VCC)
GND: C1.2, LED1.C, LED2.C, LED3.C, LED4.C, LED5.C, LED6.C, LED7.C, LED8.C, S8.4, U1.1 (A0), U1.2 (A1), U1.12 (GND), U1.21 (A2)
LED0: R14.1, S0.4
LED1: R14.2 (1), S1.4
LED2: R14.3 (1), S2.4
LED3: R14.4 (1), S3.4
LED4: R15.5 (2), S4.4
LED5: R15.6 (2), S5.4
LED6: R15.7 (2), S6.4
LED7: R15.8 (2), S7.4
unnamed: LED1.A, R14.8 (2)
unnamed: R5.1, U1.3 (!RESET)
unnamed: LED2.A, R14.7 (2)
unnamed: LED3.A, R14.6 (2)
unnamed: LED4.A, R14.5 (2)
unnamed: LED5.A, R15.1
unnamed: LED6.A, R15.2 (1)
unnamed: LED7.A, R15.3 (1)
unnamed: LED8.A, R15.4 (1)
SC0: R1.2 (1), S0.2, U1.5 (SC0)
SC1: R1.4 (1), S1.2, U1.7 (SC1)
SC2: R2.2 (1), S2.2, U1.9 (SC2)
SC3: R2.4 (1), S3.2, U1.11 (SC3)
SC4: R3.2 (1), S4.2, U1.14 (SC4)
SC5: R3.4 (1), S5.2, U1.16 (SC5)
SC6: R4.2 (1), S6.2, U1.18 (SC6)
SC7: R4.4 (1), S7.2, U1.20 (SC7)
SCL: S8.2, U1.22 (SCL)
SD0: R1.1, S0.3, U1.4 (SD0)
SD1: R1.3 (1), S1.3, U1.6 (SD1)
SD2: R2.1, S2.3, U1.8 (SD2)
SD3: R2.3 (1), S3.3, U1.10 (SD3)
SD4: R3.1, S4.3, U1.13 (SD4)
SD5: R3.3 (1), S5.3, U1.15 (SD5)
SD6: R4.1, S6.3, U1.17 (SD6)
SD7: R4.3 (1), S7.3, U1.19 (SD7)
SDA: S8.3, U1.23 (SDA)
SHIELD: S0.SH1 (SHIELD), S0.SH2 (SHIELD), S1.SH1 (SHIELD), S1.SH2 (SHIELD), S2.SH1 (SHIELD), S2.SH2 (SHIELD), S3.SH1 (SHIELD), S3.SH2 (SHIELD), S4.SH1 (SHIELD), S4.SH2 (SHIELD), S5.SH1 (SHIELD), S5.SH2 (SHIELD), S6.SH1 (SHIELD), S6.SH2 (SHIELD), S7.SH1 (SHIELD), S7.SH2 (SHIELD), S8.SH1 (SHIELD), S8.SH2 (SHIELD)

Notes on the sheet:
INPUT
OUTPUT
STATUS
MULTIPLEXER

Board: 2 copper layers, 27.7 x 31.4 mm, 29 parts (5 on the bottom side), 38 nets.

## EAGLE design Robomaster-Controller-Board-v4.0/RMCB4.brd

File Robomaster-Controller-Board-v4.0/readme.md:

# Robomaster-Controller-Board-v4.0:+1:
This board controls the movement of engineering robot's arm and makes it able to grab box of ammos. This board **REQUIRES** 24V Input.

## Components

**Relays**

 There are four relays on the board, three of them controls the robot arm's three different motion: vertical, horizontal, and rotational. The rest one is a back up relay.

**Sensors**
  1. Ammo-Detection Sensor 
  2. Limit Switch
  3. Vision
  4. TOF

**Bluetooth**

Bluetooth enables us to control the engineer robot with our phone.

**Buck Converter**

The buck converter receives 24V input and outputs 3.3V for the microcontroller.

**LED**

LED is for debugging.

## Connectors
| Connector Name  | Connected Object | 
| ------------- | ------------- |
| I2C_1 () | IMU (Address: Ch 3, IMU: 1101011 - supply) |
| I2C_2 () | Multi Plexer (Three TOFs) (Address: Ch 1, ToF 1: 1101010 - ground; Ch 2, ToF 2: 1101010 - ground; Ch 3, ToF 3: 1101010 - ground) |
| I2C_3 () | IMU_extra  |
| I2C_4 () | Multi Plexer_extra |
| RELAY1 | Vertical Pneumatic Control (24V output) |
| RELAY2 | Horizontal Pneumatic Control (24V output) |
| RELAY3 | Rotational Pneumatic Control (24V output) |
| CANBUS | Arm Motors |

## Schematic & Board Design
Pin Connections

Micro Controller

Buck Converter

Bluetooth Module

Connectors

Parts:
24V: XT30PW-M; XT30PWM
AMMO_DETEC: BM03-GHS_TBT; BM03-GHS-TBT
AUX1, AUX2: S2B-PH-SM4_TB
C1: 22u; C1206
C2: 0.1u; C0603
C3: 150p; C0603
C4: 10u; C1206
C5, C6: 1uF; C0603
C7, C9, C10: 10uF; 0603-NO
C8, C11, C12, C13, C14, C16: 1uF; 0603-NO
C15: 47nF; 0603-NO
C17, C23, C24, C25: 22pF; 0603-NO
C18, C22: 0.1uF; C0603
C19, C20, C21: 10µF; C0603
C26: 100nF; C0603
CANBUS, CANBUS1: S2B-ZR-SM4A-TF(LF)(SN); JST_S2B-ZR-SM4A-TF(LF)(SN)
CAN_CONVERTER: TJA1050; SOT96-1
D1: RED; CHIPLED_0805_NOOUTLINE
D2: PESD1CAN; SOT23-3
D3: SMD-DIODE-SCHOTTKY-40V-3A(DO-214AB); DO-214AB
D4: GREEN; CHIPLED_0805_NOOUTLINE
D5: MBR054; SOD-123
DIPSWITCH: 1571983-3; SWSO4_300X100P50B
FB1: ferrite; 0805-NO@1
I2C_1, I2C_2, I2C_4, I2C_5: SM04B-GHS-TB(LF)(SN)-; JST_SM04B-GHS-TB(LF)(SN)-
IMU: LSM6DS33; LGA16_3X3MM
L2: 4.7u; MHCI0603-4R7M-R8
MAIN_BOARD: S3B-PH-SM4_TB
NEO: WS2812B3535; LED3535
PC13: LEDCHIPLED_0603; CHIPLED_0603
POW: LEDCHIPLED_0603; CHIPLED_0603
PROGRAMMER: JTAG-CORTEX; 2X05_1.27MM_SMT
Q1: 3.1A/30V/105mΩ; SOT23-3
QWIIC: STEMMA_I2C_QT; JST_SH4
R1, R2, R20: 10K; R0603
R3: 2K; R0603
R4, R5: 100k; R0603
R6: 24k; R0603
R7: 40.2K; 0603
R8: 125K; 0603
R9, R10: 1K; R0603
R11, R13, R19: 100K; R0603
R12, R27: 2.2K; R0603
R17, R18: 5.1K; R0603
R24: 4.7K; R0603
R25, R26: 60; R0603
REFF1: 100k; R0603
RELAY1, RELAY2, RELAY3, RELAY4: S2B-PH-SM4_TB
RESET: KMR2; BTN_KMR2_4.6X2.8
RN1, RN2: 10k; 0805-ARV
SPI_FLASH: 25Q16; SOIC8_150MIL
SSR1, SSR2, SSR3, SSR4: G3VM-61VY2; SOP254P700X230-4N
STM32F405RGTX: STM32F405R; TQFP64
SWITCH: S3B-PH-SM4_TB
U1: NRF51822_MODULE_MDBT40; BLE_MODULE_RAYTAC_MDBT40
U2: AP2112-3.3; SOT23-5
U$10: MP1584_V2
USB_C: USB_C; USB_C_CUSB31-CFM2AX-01-X
VISION: S4B-PH-SM4_TB
X4: 32.768; XTAL3215
X8: MICROSD
Y2: 12mhz; CRYSTAL_2.5X2

Connections:
3.3V: C1.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.1, C26.1, CAN_CONVERTER.3 (VCC), DIPSWITCH.2, FB1.1, I2C_1.1, I2C_2.1, I2C_4.1, I2C_5.1, IMU.1 (VDDIO), IMU.16 (VDD), L2.P$2 (2), NEO.2 (VDD), PROGRAMMER.1 (VCC), QWIIC.2 (V+), R1.2, R2.2, R8.2, R27.1, RN1.7 (2), RN1.8 (2), RN2.6 (2), RN2.7 (2), SPI_FLASH.3 (WP#/IO2), SPI_FLASH.7 (HOLD#/IO3), SPI_FLASH.8 (VCC), STM32F405RGTX.19 (VDD_1), STM32F405RGTX.32 (VDD_2), STM32F405RGTX.48 (VDD_3), STM32F405RGTX.64 (VDD_4), U1.3 (AVDD), U1.14 (VDD), U1.24 (P0.07), U2.5 (OUT), VISION.1 (JST1), X8.4 (SD_VDD)
3V3EN: R5.1, R6.2, U$10.EN
24V: 24V.2, C4.1, Q1.1 (G), R5.2, SSR1.4 (D2), SSR2.4 (D2), SSR3.4 (D2), SSR4.4 (D2), U$10.VIN
!RESET: C18.1, PROGRAMMER.10 (NRESET), RESET.A, RESET.A' (P1), STM32F405RGTX.7 (NRST)
AMMO1: AMMO_DETEC.1, STM32F405RGTX.20 (PA4/ADC12_IN4)
AMMO2: AMMO_DETEC.2, STM32F405RGTX.21 (PA5/ADC12_IN5)
BOARD_RX: MAIN_BOARD.2 (JST2), STM32F405RGTX.15 (PA1/ADC123_IN1(5T))
BOARD_TX: MAIN_BOARD.1 (JST1), STM32F405RGTX.14 (PA0/ADC123_IN0(5T))
BOOT0: R13.1, STM32F405RGTX.60 (BOOT0)
BST1: C2.1, U$10.BST
CANRX_N: CAN_CONVERTER.4 (RXD), STM32F405RGTX.44 (PA11/TIM1_CH4/CANRX/USBDM(5T))
CANTX_P: CAN_CONVERTER.1 (TXD), STM32F405RGTX.45 (PA12/CANTX/USBDP(5T))
CAN_N: CANBUS.2, CANBUS1.2, CAN_CONVERTER.6 (CANL), D2.2, R25.2
CAN_P: CANBUS.1, CANBUS1.1, CAN_CONVERTER.7 (CANH), D2.1, R26.2
CC1: R18.2, USB_C.A5 (CC1)
CC2: R17.2, USB_C.B5 (CC2)
COMP_3V3: C3.1, U$10.COMP
CONNECTED_LED: R10.1, U1.39 (P0.19)
D11: SSR1.1 (A), STM32F405RGTX.11 (PC3/ADC123_IN13(5T))
D12: SSR2.1 (A), STM32F405RGTX.10 (PC2/ADC123_IN12(5T))
D13: SSR3.1 (A), STM32F405RGTX.9 (PC1/ADC123_IN11(5T))
D14: SSR4.1 (A), STM32F405RGTX.8 (PC0/ADC123_IN10(5T))
D+: USB_C.A6 (D+), USB_C.B6 (D+)
D-: USB_C.A7 (D-), USB_C.B7 (D-)
DCC: U1.15 (DCC)
DEC2: U1.41 (DEC2)
EN: R20.1, U2.3 (EN)
FB_3V3: R7.2, R8.1, U$10.FB
FLASH_CS: R1.1, SPI_FLASH.1 (SSEL), STM32F405RGTX.50 (PA15/JTDI(5T))
FLASH_MISO: SPI_FLASH.2 (MISO), STM32F405RGTX.56 (PB4/JNTRST(5T))
FLASH_MOSI: R11.1, SPI_FLASH.5 (MOSI), STM32F405RGTX.57 (PB5(5T))
FLASH_SCK: SPI_FLASH.6 (SCK), STM32F405RGTX.55 (PB3/JTDO(5T))
FREQ1: REFF1.1, U$10.FREQ
GND: 24V.1, AMMO_DETEC.3, AUX1.2 (JST3), AUX2.2 (JST3), C1.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, CAN_CONVERTER.2 (GND), D1.C, D2.3, D3.1 (+), D4.C, I2C_1.4, I2C_2.4, I2C_4.4, I2C_5.4, IMU.8 (GND), IMU.9 (GND), IMU.10 (GND), IMU.11 (GND), IMU.12 (GND), IMU.13 (GND), IMU.15 (GND), MAIN_BOARD.3 (JST3), NEO.4 (GND), PC13.C, POW.C, PROGRAMMER.3 (GND), PROGRAMMER.5 (GND), PROGRAMMER.7 (KEY), PROGRAMMER.9 (GNDDETECT), QWIIC.1 (GND), QWIIC.MT1 (MT), QWIIC.MT2 (MT), R3.1, R4.1, R6.1, R7.1, R11.2, R13.2, R17.1, R18.1, R19.1, R24.1, REFF1.2, RELAY1.2 (JST3), RELAY2.2 (JST3), RELAY3.2 (JST3), RELAY4.2 (JST3), RESET.B (S), RESET.B' (S1), SPI_FLASH.4 (VSS), SSR1.2 (K), SSR2.2 (K), SSR3.2 (K), SSR4.2 (K), STM32F405RGTX.12 (VSSA), STM32F405RGTX.18 (VSS_1), STM32F405RGTX.28 (PB2/BOOT1(5T))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
GPIO_AUX1: AUX1.1 (JST2), STM32F405RGTX.25 (PC5/ADC12_IN15)
GPIO_AUX2: AUX2.1 (JST2), STM32F405RGTX.24 (PC4/ADC12_IN14)
I2C-1_CL: I2C_1.2, I2C_4.2, IMU.2 (SCL), QWIIC.4 (SCL), RN2.2 (1), STM32F405RGTX.58 (PB6/I2C1_SCL/USART1_TX/TIM4_CH1(5T))
I2C-1_DA: I2C_1.3, I2C_4.3, IMU.3 (SDA), QWIIC.3 (SDA), RN2.3 (1), STM32F405RGTX.59 (PB7/I2C1_SDA/USART1_RX/TIM4_CH2(5T))
I2C-2_CL: I2C_2.2, I2C_5.2, RN1.1, STM32F405RGTX.29 (PB10/I2C2_SCL(5T))
I2C-2_DA: I2C_2.3, I2C_5.3, RN1.2 (1), STM32F405RGTX.30 (PB11/I2C2_SDA(5T))
MODE_3V: DIPSWITCH.3, R3.2, U1.18 (P0.01/AIN2)
MODE_LED: R9.1, U1.38 (P0.18)
unnamed: C3.2, R4.2
unnamed: D1.A, R9.2
unnamed: D4.A, R10.2
unnamed: C25.1, STM32F405RGTX.3 (PC14/OSC32_IN(5T)), X4.P$1
unnamed: C23.1, STM32F405RGTX.4 (PC15/OSC32_OUT(5T)), X4.P$2
unnamed: C24.1, STM32F405RGTX.5 (PH0/OSC_IN(5T)), Y2.3 (2)
unnamed: C17.1, STM32F405RGTX.6 (PH1/OSC_OUT(5T)), Y2.1
unnamed: PC13.A, R12.2
unnamed: C21.1, C22.1, FB1.2, STM32F405RGTX.13 (VDDA)
unnamed: CAN_CONVERTER.8 (S), R24.2
unnamed: C15.1, R25.1, R26.1
unnamed: POW.A, R27.2
unnamed: D5.C, Q1.3 (D)
NEOPIX: NEO.1 (DI), STM32F405RGTX.41 (PA8/TIM1_CH1(5T))
PB0: STM32F405RGTX.26 (PB0/TIM1_CH2N/ADC12_IN8(5T))
PB1: STM32F405RGTX.27 (PB1/TIM1_CH3N/ADC12_IN9(5T))
PB8: STM32F405RGTX.61 (PB8/TIM10_CH1/TIM4_CH3(5T))
PB9: STM32F405RGTX.62 (PB9/TIM11_CH1/TIM4_CH4(5T))
PB13: STM32F405RGTX.34 (PB13/SPI2_SCK(5T))
PB14: STM32F405RGTX.35 (PB14/SPI2_MISO(5T))
PB15: STM32F405RGTX.36 (PB15/SPI2_MOSI(5T))
PC6: STM32F405RGTX.37 (PC6/TIM3_CH1/TIM_CH1/USART6_TX(5T))
PC7: STM32F405RGTX.38 (PC7/TIM3_CH2/TIM8_CH2/USART6_RX(5T))
PC13: R12.1, STM32F405RGTX.2 (PC13(5T))
RELAY1: RELAY1.1 (JST2), SSR1.3 (D1)
RELAY2: RELAY2.1 (JST2), SSR2.3 (D1)
RELAY3: RELAY3.1 (JST2), SSR3.3 (D1)
RELAY4: RELAY4.1 (JST2), SSR4.3 (D1)
RTS: U1.26 (P0.08)
RX_BT: STM32F405RGTX.17 (PA3/ADC123_IN3(5T)), U1.29 (P0.11)
SDIO_CLK: STM32F405RGTX.53 (PC12(5T)), X8.5 (SCLK)
SDIO_CMD: STM32F405RGTX.54 (PD2/TIM3_ETR(5T)), X8.3 (DATA_IN)
SDIO_D0: STM32F405RGTX.39 (PC8/TIM3_CH3/TIM8_CH3(5T)), X8.7 (DATA_OUT)
SDIO_D1: STM32F405RGTX.40 (PC9/TIM3_CH4/TIM8_CH4(5T)), X8.8 (DAT1)
SDIO_D2: STM32F405RGTX.51 (PC10(5T)), X8.1 (DAT2)
SDIO_D3: R2.1, STM32F405RGTX.52 (PC11(5T)), X8.2 (CS)
SD_DETECT: STM32F405RGTX.33 (PB12(5T)), X8.CD2 (CARD_DETECT1)
SHIELD: I2C_1.SH1 (SHIELD), I2C_1.SH2 (SHIELD), I2C_2.SH1 (SHIELD), I2C_2.SH2 (SHIELD), I2C_4.SH1 (SHIELD), I2C_4.SH2 (SHIELD), I2C_5.SH1 (SHIELD), I2C_5.SH2 (SHIELD)
SW1: C2.2, D3.2 (-), L2.P$1 (1), U$10.SW
SWCLK: PROGRAMMER.4 (SWDCLK), STM32F405RGTX.49 (PA14/JTCK-SWCLK(5T))
SWDIO: PROGRAMMER.2 (SWDIO), STM32F405RGTX.46 (PA13/JTMS-SWDAT(5T))
SWITCH1: STM32F405RGTX.22 (PA6/ADC12_IN6(5T)), SWITCH.1 (JST1)
SWITCH2: STM32F405RGTX.23 (PA7/TIM1_CH1N/ADC12_IN7(FT)), SWITCH.2 (JST2)
TX_BT: STM32F405RGTX.16 (PA2/ADC123_IN2(5T)), U1.27 (P0.09)
VBUS: D5.A, R19.2, USB_C.A4B9 (VBUS), USB_C.B4A9 (VBUS)
VCAP1: C19.1, STM32F405RGTX.31 (VCAP_1)
VCAP2: C20.1, STM32F405RGTX.47 (VCAP_2)
VHI: C7.1, Q1.2 (S), R20.2, U2.1 (IN)
VISION_RX: STM32F405RGTX.43 (PA10/TIM1_CH3/USART1_RX(5T)), VISION.3 (JST3)
VISION_TX: STM32F405RGTX.42 (PA9/TIM1_CH2/USART1_TX(5T)), VISION.2 (JST2)

Notes on the sheet:
USART3
I2S2_WS
I2S2_BCLK
DATA
CMD
CTS - Clear to Send hardware flow control pin into the the breakou (MCU --> Bluefruit LE). Use this pin to tell the Bluefruit that it can send data back to the microcontroller over the TXO pin. This pin is pulled high by default and must be set to ground in order to enable data transfer out! If you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
CTS

Board: 4 copper layers, 57.5 x 49.2 mm, 97 parts (33 on the bottom side), 80 nets.

File Robomaster-Controller-Board-v4.0/Document/CB4_BOM.xlsx (part):

Qty | Value | Device | Package | Links | Parts | Description | AVAILABILITY | DESCRIPTION.1 | HEIGHT | MANUFACTURER_NAME | MANUFACTURER_PART_NUMBER | MF | MOUSER_PART_NUMBER | MOUSER_PRICE-STOCK | MP | PACKAGE.1 | POPULARITY | PRICE | PROD_ID | RS_PART_NUMBER | RS_PRICE-STOCK | SPICEPREFIX | VALUE.1 | Column1
2 | 10k | 1KOHM-ARRAY(4)-0805_ARV-1/10W-5% | 0805-ARV |  | RN1, RN2 | 4 x 1kÎ© resistor array |  |  |  |  |  |  |  |  |  |  |  |  | RES-13020 |  |  |  | 1k
1 | 40.2K | 220KOHM-0603-1/10W-1% | 0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R7 | 220kÎ© resistor |  |  |  |  |  |  |  |  |  |  |  |  | RES-08969 |  |  |  | 220k
1 | BM03-GHS_TBT | BM03-GHS_TBT | BM03-GHS-TBT |  | AMMO_DETEC
1 | 100nF | CAP_CERAMIC0603_NO | 0603-NO | https://www.digikey.com/product-detail/en/kemet/C0603C104Z3V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 | C26 | Ceramic Capacitors
7 | 10uF | CAP_CERAMIC0603_NO | 0603-NO | https://www.digikey.com/product-detail/en/murata-electronics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 | C7, C9, C10 | Ceramic Capacitors
6 | 1uF | CAP_CERAMIC0603_NO | 0603-NO | https://www.digikey.com/product-detail/en/samsung-electro-me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 | C5, C6, C8, C11, C12, C13, C14, C16 | Ceramic Capacitors
4 | 22pF | CAP_CERAMIC0603_NO | 0603-NO | https://www.digikey.com/product-detail/en/%E5%9E%88%ED%9B%87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 | C17, C23, C24, C25 | Ceramic Capacitors
1 | 47nF | CAP_CERAMIC0603_NO | 0603-NO | https://www.digikey.com/product-detail/en/%E5%9E%88%ED%9B%87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 | C15 | Ceramic Capacitors
3 | 0.1uF | C-EUC0603 | C0603 | https://www.digikey.com/product-detail/en/kemet/C0603C104Z3V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 | C2, C18, C22 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  | 73 |  |  |  |  | C
1 | 12mhz | CRYSTAL2.5X2.0 | CRYSTAL_2.5X2 | https://www.digikey.com/product-detail/en/ndk-america-inc/NX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 | Y2 | Crystals
1 | 150p | C-USC0603 | C0603 | https://www.digikey.com/product-detail/en/kemet/C0603C151J5G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 | C3 | CAPACITOR, American symbol
1 | o | C-USC1206 | C1206 | https://www.digikey.com/product-detail/en/murata-electronics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 | C1 | CAPACITOR, American symbol
1 | MBR054 | DIODE-SCHOTTKYSOD-123 | SOD-123 | https://www.digikey.com/product-detail/en/micro-commercial-c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 | D5
1 | ferrite | FERRITE-0805NO | 0805-NO@1 | https://www.digikey.com/product-detail/en/taiyo-yuden/BKP212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 | FB1 | Ferrite Bead
4 | G3VM-61VY2 | G3VM-61VY2 | SOP254P700X230-4N | https://www.digikey.com/product-detail/en/omron-electronics-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 | SSR1, SSR2, SSR3, SSR4 | Solid State Relays - PCB Mount Mos Fet Relay, SMT 60V, 1 form A,SOP4 |  | Solid State Relays - PCB Mount Mos Fet Relay, SMT 60V, 1 form A,SOP4 | 2.3mm | Omron Electronics | G3VM-61VY2 |  | 653-G3VM61VY2 | https://www.mouser.com/Search/Refine.aspx?Keyword=653-G3VM61VY2
1 |  | JTAG-CORTEX | 2X05_1.27MM_SMT | https://www.digikey.com/product-detail/en/cnc-tech/3220-10-0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 | PROGRAMMER | Serial Wire (SW-DP) Connector
2 | GREEN | LEDCHIPLED_0603 | CHIPLED_0603 | https://www.digikey.com/product-detail/en/kingbright/APT1608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 | PC1, POW | LED
2 | RED | LEDCHIPLED_0603 | CHIPLED_0603 | https://www.digikey.com/product-detail/en/kingbright/APT1608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 | PC1, POW | LED
1 | LSM6DS33 | LSM6DS33 | LGA16_3X3MM | https://www.digikey.com/product-detail/en/stmicroelectronics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 | IMU
1 | 4.7u | MHCI0603-4R7M-R8 | MHCI0603-4R7M-R8 | https://www.digikey.com/product-detail/en/taiyo-yuden/MBKK16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 | L2
1 |  | MICROSD | MICROSD |  | X8 | MicroSD/Transflash Card Holder with SPI pinout
1 | 3.1A/30V/105mÎ© | MOSFET_PCH-DMG2307L | SOT23-3 |  | Q1 | P-channel MOSFETs |  |  |  |  |  |  |  |  |  |  |  |  | TRANS-11308 |  |  |  | 3.1A/30V/105mÎ©
1 | MP1584_V2 | MP1584_V2 | MP1584_V2 | https://www.digikey.com/product-detail/en/monolithic-power-s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 | U$10
1 |  | NRF51822_MODULE_MDBT40 | BLE_MODULE_RAYTAC_MDBT40 | https://www.digikey.com/product-detail/en/nordic-semiconduct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 | U1 | nRF51822 Bluetooth Low Energy Module
1 | PESD1CAN | PESD1CAN | SOT23-3 | https://www.digikey.com/product-detail/en/nexperia-usa-inc/P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 | D2 | PESD1CAN is used to protect two automotive CAN bus lines from ESD. | Unavailable | 50V Clamp 3A _8/20Âµs_ Ipp Tvs Diode Surface Mount SC-70 |  |  |  | NXP Semiconductors |  |  | PESD1CAN | SC-70 NXP Semiconductors |  | None
1 | 125K->127K | RESISTOR0603 | 0603 | https://www.digikey.com/product-detail/en/te-connectivity-pa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 | R8 | Generic Resistor Package
6 | 100k | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/bourns-inc/CR0603-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 | R4, R5, REFF1 | RESISTOR, American symbol
3 | 10K | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/bourns-inc/CR0603-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 | R1, R2, R20 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  | 77 |  |  |  |  | R
2 | 1K | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R9, R10 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  | 77 |  |  |  |  | R
2 | 2.2K | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R12, R27 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  | 77 |  |  |  |  | R
1 | 24k | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R6 | RESISTOR, American symbol
1 | 2K | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R14 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  | 77 |  |  |  |  | R
1 | 4.7K | R-US_R0603 | R0603 | https://www.digikey.com/products/en/resistors/chip-resistor-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 | R24 | RESISTOR, American symbol
2 | 5.1K | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R17, R18 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  | 77 |  |  |  |  | R
2 | 60->60.4 | R-US_R0603 | R0603 | https://www.digikey.com/product-detail/en/stackpole-electron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 | R25, R26 | RESISTOR, American symbol
5 | S2B-PH-SM4_TB | S2B-PH-SM4_TB | S2B-PH-SM4_TB | https://www.digikey.com/product-detail/en/jst-sales-america-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 | AUX_GPIO2, RELAY1, RELAY2, RELAY3, RELAY4
2 | S2B-ZR-SM4A-TF(LF)(SN) | S2B-ZR-SM4A-TF(LF)(SN) | JST_S2B-ZR-SM4A-TF(LF)(SN) | https://www.digikey.com/product-detail/en/jst-sales-america-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 | CANBUS, CANBUS1 | ZH Series 2 Position 1.5 mm Pitch Surface Mount Side Entry Shrouded Header | Unavailable | Connector Header Surface Mount, Right Angle 2 position 0.059 _1.50mm_ |  |  |  | JST Sales |  |  | S2B-ZR-SM4A-TF_LF__SN_ | None |  | None
2 | S3B-PH-SM4_TB | S3B-PH-SM4_TB | S3B-PH-SM4_TB | https://www.digikey.com/product-detail/en/jst-sales-america-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 | MAIN_BOARD, SWITCH
1 | S4B-PH-SM4_TB | S4B-PH-SM4_TB | S4B-PH-SM4_TB | https://www.digikey.com/product-detail/en/jst-sales-america-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 | VISION
6 | SM04B-GHS-TB(LF)(SN)- | SM04B-GHS-TB(LF)(SN)- | JST_SM04B-GHS-TB(LF)(SN)- | https://www.digikey.com/product-detail/en/jst-sales-america-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 | I2C_1, I2C_2, I2C_3, I2C_4, I2C_5, I2C_6 | Conn Header Gh Side 4pos 1.25mm | Unavailable | Connector Header Surface Mount, Right Angle 4 position 0.049 _1.25mm_ |  |  |  | JST Sales |  |  | SM04B-GHS-TB_LF__SN_- | None |  | None
1 | SMD-DIODE-SCHOTTKY-40V-3A(DO-214AB) | SMD-DIODE-SCHOTTKY-40V-3A(DO-214AB) | DO-214AB | kevin got it | D3 | 304020018 | Unavailable | Rectifier, Schottky | DO-214AB | 3.0A IF | 0.75V | 40V | 100A IFRM | 10000V/us | 1000pF |  |  |  | Vishay |  |  | SS34-E3/57T | DO-214 Vishay
1 | 25Q16 | SPIFLASH_8PIN | SOIC8_150MIL | https://www.digikey.com/product-detail/en/winbond-electronic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 | SPI_FLASH | SOIC8 SPI Flash
1 | STEMMA_I2C_QT | STEMMA_I2C_QT | JST_SH4 |  | QWIIC
1 | STM32F405R | STM32F405R | TQFP64 | https://www.digikey.com/product-detail/en/stmicroelectronics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 | STM32F405RGTX | STM32F405 64 pin LQFP
1 | EG1319 | SWITCH_DPDTEG1390 | EG1390 | kevin gonna replace | SW1 | Switch - DPDT
1 | KMR2 | SWITCH_TACT_SMT4.6X2.8 | BTN_KMR2_4.6X2.8 | https://www.digikey.com/product-detail/en/c-k/KMR221GLFS/401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 | RESET | SMT Tact Switches
1 | TJA1050 | TJA1050 | SOT96-1 | https://www.digikey.com/product-detail/en/nxp-usa-inc/TJA105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 | CAN_CONVERTER | High speed CAN transceiver | Unavailable | 1/1 Transceiver Half CANbus 8-SO |  |  |  | NXP USA |  |  | TJA1050 | SOIC-8 NXP USA |  | None
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

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
