# Repository RoboMaster-Club/Electrical-System (continued)

## EAGLE design Robomaster-Controller-Board-v4.0/Draft_1/Adafruit Feather STM32F405 Express.brd

File Robomaster-Controller-Board-v4.0/Readme.md:

# Robomaster-Controller-Board-v4.0:+1:
This board controls the movement of engineering robot's arm and makes it able to grab box of ammos.

## Components

**Relays**
 
 There are four relays on the board, three of them controls the robot arm's three different motion: vertical, horizontal, and rotational. The rest one is a back up relay.

**Sensors**
  1. Ammo-Detection Sensor 
  2. Limit Switch
  3. Vision
  4. TOF
  
**Bluetooth**

**Buck Converter**

**LED**
  
## Connectors
| Connector Name  | Connected Object |
| ------------- | ------------- |
| I2C_1  | TOF1  |
| I2C_2  | TOF2  |
| I2C_3  | TOF3  |
| I2C_4 | TOF1_Extra |
| I2C_5 | TOF2_Extra  |
| I2C_6  | TOF3_Extra  |
| RELAY1 | Vertical Pneumatic Control |
| RELAY2 | Horizontal Pneumatic Control  |
| RELAY3 | Rotational Pneumatic Control  |
| CANBUS | Arm Motors |

Parts:
AUX_GPIO1, AUX_GPIO2: S2B-PH-SM4_TB
C1: 22u; C1206
C2: 0.1u; C0603
C3: 150p; C0603
C4: 10u; C1206
C5, C6: 1uF; 0805-NO
C18, C22: 0.1uF; 0603-NO
C19, C20, C21: 10µF; 0805-NO
C23, C27: 22pF; RESPACK_4X0603
C28: 47nF; RESPACK_4X0603
CANBUS, CANBUS1: S2B-ZR-SM4A-TF(LF)(SN); JST_S2B-ZR-SM4A-TF(LF)(SN)
CAN_CONVERTER: TJA1050; SOT96-1
D1: RED; CHIPLED_0805_NOOUTLINE
D2: PESD1CAN; SOT23-3
D3: SMD-DIODE-SCHOTTKY-40V-3A(DO-214AB); DO-214AB
D4: GREEN; CHIPLED_0805_NOOUTLINE
D+1: TPB1,27; B1,27
D-1: TPB1,27; B1,27
FB1: ferrite; 0805-NO@1
I2C_1, I2C_2, I2C_3, I2C_4, I2C_5, I2C_6: SM04B-GHS-TB(LF)(SN)-; JST_SM04B-GHS-TB(LF)(SN)-
IMU: LSM6DS33; LGA16_3X3MM
J1: XT30PW-M; XT30PWM
L2: 4.7u; MHCI0603-4R7M-R8
LED2: WS2812B3535; LED3535
MAIN_BOARD: S3B-PH-SM4_TB
PC1_PLED: RED; CHIPLED_0805_NOOUTLINE
POW: LEDCHIPLED_0603; CHIPLED_0603
PROGRAMMER: JTAG-CORTEX; 2X05_1.27MM_SMT
R1, R2, R3: 10K; RESPACK_4X0603
R4, R5: 100k; R0603
R6: 24k; R0603
R7: 40.2K; 0603
R8: 125K; 0603
R9, R10: 1K; 0805-NO
R11: 100K; RESPACK_4X0603_NO
R12, R27: 2.2K; 0603-NO
R13: 100K; 0603-NO
R14: 2K; 0805-NO
R15, R16: 10K; RESPACK_4X0603_NO
R17, R18: 5.1K; 0603-NO
R24: 4.7K; R0603
R25, R26: 60; R0603
REFF1: 100k; R0603
RELAY1, RELAY2, RELAY3: S2B-PH-SM4_TB
RESET: KMR2; BTN_KMR2_4.6X2.8
SPI_FLASH: 25Q16; SOIC8_150MIL
SSR1, SSR2, SSR3: G3VM-61VY2; SOP254P700X230-4N
SW1: EG1319; EG1390
SWITCH: S3B-PH-SM4_TB
U1: NRF51822_MODULE_MDBT40; BLE_MODULE_RAYTAC_MDBT40
U$6: BM03-GHS_TBT; BM03-GHS-TBT
U$10: MP1584_V2
U$40: STM32F405R; TQFP64
USB_C: USB_C; USB_C_CUSB31-CFM2AX-01-X
VISION: S4B-PH-SM4_TB
X4: 32.768; XTAL3215
X8: MICROSD
Y2: 12mhz; CRYSTAL_2.5X2

Connections:
3.3V: C1.1, C5.1, C6.1, CAN_CONVERTER.3 (VCC), FB1.1, I2C_1.1, I2C_2.1, I2C_3.1, I2C_4.1, I2C_5.1, I2C_6.1, IMU.1 (VDDIO), IMU.16 (VDD), L2.P$2 (2), LED2.2 (VDD), PROGRAMMER.1 (VCC), R1.2 (1), R1.4 (1), R2.2 (1), R2.4 (1), R3.2 (1), R3.4 (1), R8.2, R15.5 (2), R16.6 (2), R27.1, SPI_FLASH.3 (WP#/IO2), SPI_FLASH.7 (HOLD#/IO3), SPI_FLASH.8 (VCC), SW1.O2, U1.3 (AVDD), U1.14 (VDD), U1.24 (P0.07), U$40.19 (VDD_1), U$40.32 (VDD_2), U$40.42 (PA9/TIM1_CH2/USART1_TX(5T)), U$40.43 (PA10/TIM1_CH3/USART1_RX(5T)), U$40.48 (VDD_3), U$40.64 (VDD_4), VISION.1 (JST1), X8.4 (SD_VDD)
3V3EN: R5.1, R6.2, U$10.EN
24V: C4.1, J1.2, R5.2, SSR1.4 (D2), SSR2.4 (D2), SSR3.4 (D2), U$10.VIN
!RESET: C18.1, PROGRAMMER.10 (NRESET), RESET.A, RESET.A' (P1), U$40.7 (NRST)
AMMO1: U$6.1, U$40.20 (PA4/ADC12_IN4)
AMMO2: U$6.2, U$40.21 (PA5/ADC12_IN5)
BACKUP1: U$40.24 (PC4/ADC12_IN14)
BACKUP2: AUX_GPIO2.1 (JST2), U$40.25 (PC5/ADC12_IN15)
BAKCUP1: AUX_GPIO1.1 (JST2)
BOARD_RX: MAIN_BOARD.2 (JST2), U$40.15 (PA1/ADC123_IN1(5T))
BOARD_TX: MAIN_BOARD.1 (JST1), U$40.14 (PA0/ADC123_IN0(5T))
BOOT0: R13.1, U$40.60 (BOOT0)
BST1: C2.1, U$10.BST
CANRX_N: CAN_CONVERTER.4 (RXD), U$40.44 (PA11/TIM1_CH4/CANRX/USBDM(5T))
CANTX_P: CAN_CONVERTER.1 (TXD), U$40.45 (PA12/CANTX/USBDP(5T))
CAN_N: CANBUS.2, CANBUS1.2, CAN_CONVERTER.6 (CANL), D2.2, R25.2
CAN_P: CANBUS.1, CANBUS1.1, CAN_CONVERTER.7 (CANH), D2.1, R26.2
CC1: R18.2, USB_C.A5 (CC1)
CC2: R17.2, USB_C.B5 (CC2)
COMP_3V3: C3.1, U$10.COMP
CONNECTED_LED: R10.1, U1.39 (P0.19)
CTS: U1.28 (P0.10)
D8_NEOPIX: LED2.1 (DI), U$40.8 (PC0/ADC123_IN10(5T))
D9: U$40.61 (PB8/TIM10_CH1/TIM4_CH3(5T))
D10: U$40.62 (PB9/TIM11_CH1/TIM4_CH4(5T))
D11: SSR1.1 (A), U$40.11 (PC3/ADC123_IN13(5T))
D12: SSR2.1 (A), U$40.10 (PC2/ADC123_IN12(5T))
D13: R12.1, SSR3.1 (A), U$40.9 (PC1/ADC123_IN11(5T))
D+: D+1.TP, USB_C.A6 (D+), USB_C.B6 (D+)
D-: D-1.TP, USB_C.A7 (D-), USB_C.B7 (D-)
DCC: U1.15 (DCC)
DEC2: U1.41 (DEC2)
FB_3V3: R7.2, R8.1, U$10.FB
FLASH_CS: R15.4 (1), SPI_FLASH.1 (SSEL), U$40.50 (PA15/JTDI(5T))
FLASH_MISO: SPI_FLASH.2 (MISO), U$40.56 (PB4/JNTRST(5T))
FLASH_MOSI: R11.4 (1), SPI_FLASH.5 (MOSI), U$40.57 (PB5(5T))
FLASH_SCK: SPI_FLASH.6 (SCK), U$40.55 (PB3/JTDO(5T))
FREQ1: REFF1.1, U$10.FREQ
GND: AUX_GPIO1.2 (JST3), AUX_GPIO2.2 (JST3), C1.2, C4.2, C5.2, C6.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.5 (2), C23.6 (2), C23.7 (2), C27.7 (2), C28.8 (2), CAN_CONVERTER.2 (GND), D1.C, D2.3, D3.1 (+), D4.C, I2C_1.4, I2C_2.4, I2C_3.4, I2C_4.4, I2C_5.4, I2C_6.4, IMU.8 (GND), IMU.9 (GND), IMU.10 (GND), IMU.11 (GND), IMU.12 (GND), IMU.13 (GND), IMU.15 (GND), J1.1, LED2.4 (GND), MAIN_BOARD.3 (JST3), PC1_PLED.C, POW.C, PROGRAMMER.3 (GND), PROGRAMMER.5 (GND), PROGRAMMER.7 (KEY), PROGRAMMER.9 (GNDDETECT), R4.1, R6.1, R7.1, R11.5 (2), R13.2, R17.1, R18.1, R24.1, REFF1.2, RELAY1.2 (JST3), RELAY2.2 (JST3), RELAY3.2 (JST3), RESET.B (S), RESET.B' (S1), SPI_FLASH.4 (VSS), SSR1.2 (K), SSR2.2 (K), SSR3.2 (K), SW1.S2, SWITCH.3 (JST3), U1.1 (GND), U1.2 (GND), U1.13 (GND), U1.16 (P0.30), U1.25 (GND), U1.42 (GND), U$6.3, U$10.GND, U$10.GND_B, U$40.12 (VSSA), U$40.18 (VSS_1), U$40.28 (PB2/BOOT1(5T)), U$40.63 (VSS_2), USB_C.A1B12 (GND), USB_C.B1A12 (GND), VISION.4 (JST4), X8.6 (GND)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
I2C-1_CL: I2C_1.2, I2C_4.2, IMU.2 (SCL), R3.7 (2), U$40.58 (PB6/I2C1_SCL/USART1_TX/TIM4_CH1(5T))
I2C-1_DA: I2C_1.3, I2C_4.3, IMU.3 (SDA), R3.5 (2), U$40.59 (PB7/I2C1_SDA/USART1_RX/TIM4_CH2(5T))
I2C-2_CL: I2C_2.2, I2C_5.2, R1.7 (2), U$40.29 (PB10/I2C2_SCL(5T))
I2C-2_DA: I2C_2.3, I2C_5.3, R1.5 (2), U$40.30 (PB11/I2C2_SDA(5T))
I2C-3_CL: I2C_3.2, I2C_6.2, R2.7 (2), U$40.41 (PA8/TIM1_CH1(5T))
I2C-3_DA: I2C_3.3, I2C_6.3, R2.5 (2), U$40.40 (PC9/TIM3_CH4/TIM8_CH4(5T))
MISO: U$40.35 (PB14/SPI2_MISO(5T))
MODE_3V: R14.1, U1.18 (P0.01/AIN2)
MODE_LED: R9.1, U1.38 (P0.18)
MOSI: U$40.36 (PB15/SPI2_MOSI(5T))
unnamed: C3.2, R4.2
unnamed: R14.2, SW1.P2
unnamed: D1.A, R9.2
unnamed: D4.A, R10.2
unnamed: C23.4 (1), U$40.3 (PC14/OSC32_IN(5T)), X4.P$1
unnamed: C23.3 (1), U$40.4 (PC15/OSC32_OUT(5T)), X4.P$2
unnamed: C23.2 (1), U$40.5 (PH0/OSC_IN(5T)), Y2.3 (2)
unnamed: C27.2 (1), U$40.6 (PH1/OSC_OUT(5T)), Y2.1
unnamed: PC1_PLED.A, R12.2
unnamed: C21.1, C22.1, FB1.2, U$40.13 (VDDA)
unnamed: CAN_CONVERTER.8 (S), R24.2
unnamed: C28.1, R25.1, R26.1
unnamed: POW.A, R27.2
PB0: U$40.26 (PB0/TIM1_CH2N/ADC12_IN8(5T))
PB1: U$40.27 (PB1/TIM1_CH3N/ADC12_IN9(5T))
RELAY1: RELAY1.1 (JST2), SSR1.3 (D1)
RELAY2: RELAY2.1 (JST2), SSR2.3 (D1)
RELAY3: RELAY3.1 (JST2), SSR3.3 (D1)
RTS: U1.26 (P0.08)
RX_BT: U1.29 (P0.11), U$40.17 (PA3/ADC123_IN3(5T))
SCK: U$40.34 (PB13/SPI2_SCK(5T))
SDIO_CLK: U$40.38 (PC7/TIM3_CH2/TIM8_CH2/USART6_RX(5T)), X8.5 (SCLK)
SDIO_CMD: U$40.37 (PC6/TIM3_CH1/TIM_CH1/USART6_TX(5T)), X8.3 (DATA_IN)
SDIO_D0: U$40.39 (PC8/TIM3_CH3/TIM8_CH3(5T)), X8.7 (DATA_OUT)
SDIO_D1: U$40.2 (PC13(5T)), X8.8 (DAT1)
SDIO_D2: U$40.51 (PC10(5T)), X8.1 (DAT2)
SDIO_D3: R16.3 (1), U$40.52 (PC11(5T)), X8.2 (CS)
SD_DETECT: U$40.33 (PB12(5T)), X8.CD2 (CARD_DETECT1)
SHIELD: I2C_1.SH1 (SHIELD), I2C_1.SH2 (SHIELD), I2C_2.SH1 (SHIELD), I2C_2.SH2 (SHIELD), I2C_3.SH1 (SHIELD), I2C_3.SH2 (SHIELD), I2C_4.SH1 (SHIELD), I2C_4.SH2 (SHIELD), I2C_5.SH1 (SHIELD), I2C_5.SH2 (SHIELD), I2C_6.SH1 (SHIELD), I2C_6.SH2 (SHIELD)
SW1: C2.2, D3.2 (-), L2.P$1 (1), U$10.SW
SWCLK: PROGRAMMER.4 (SWDCLK), U$40.49 (PA14/JTCK-SWCLK(5T))
SWDIO: PROGRAMMER.2 (SWDIO), U$40.46 (PA13/JTMS-SWDAT(5T))
SWITCH1: SWITCH.1 (JST1), U$40.22 (PA6/ADC12_IN6(5T))
SWITCH2: SWITCH.2 (JST2), U$40.23 (PA7/TIM1_CH1N/ADC12_IN7(FT))
TX_BT: U1.27 (P0.09), U$40.16 (PA2/ADC123_IN2(5T))
VBUS: USB_C.A4B9 (VBUS), USB_C.B4A9 (VBUS)
VCAP1: C19.1, U$40.31 (VCAP_1)
VCAP2: C20.1, U$40.47 (VCAP_2)
VISION_RX: U$40.54 (PD2/TIM3_ETR(5T)), VISION.3 (JST3)
VISION_TX: U$40.53 (PC12(5T)), VISION.2 (JST2)

Notes on the sheet:
SPI1
SPI2
USART3
I2C1
I2S2_WS
I2S2_BCLK
I2S2_SD
I2S2ext_SD
CAN
DATA
CMD
CTS - Clear to Send hardware flow control pin into the the breakou (MCU --> Bluefruit LE). Use this pin to tell the Bluefruit that it can send data back to the microcontroller over the TXO pin. This pin is pulled high by default and must be set to ground in order to enable data transfer out! If you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

Board: 2 copper layers, 182.4 x 100.0 mm, 82 parts (0 on the bottom side), 76 nets.

## EAGLE design Super_Capactior_V3.0/SC_customized2.brd

Parts:
3.3V_BUCK: SOIC8E; SOIC127P600X170-9N
C1, C3, C5, C7, C9, C11, C13, C15, C17: 2.7V 60F; 2.7V_60F
C2, C4, C6, C8, C10, C12, C14, C16, C18: 100pF; 0603
C19, C20, C21, C22, C23: 0.1uF; 0603
C24: 0.22uF; 0603
D1, D2, D3, D4, D5, D6, D7, D8, D9: LM385; LM385_SOT23
D10: 5.1V; SOD-323
D11: 3A/40V/500mV; SMA-DIODE
LMP1, LMP2, LMP3, LMP4, LMP5, LMP6, LMP7, LMP8, LMP9: LMP2231; LMP2231_SOT23_5
MOS1, MOS2, MOS3, MOS4, MOS5, MOS6, MOS7, MOS8, MOS9: IRLML2502TRPBF_MOS; IRLML2502TRPBF_SOT23
PWR_IN: XT60
PWR_OUT: XT60
R1, R6, R11, R16, R21, R26, R31, R36, R41: 2.2; 2512
R2, R7, R12, R17, R22, R27, R32, R37, R42: 75k; 0603@1
R3, R8, R13, R18, R23, R28, R33, R38, R43: 68k; 0603@1
R4, R9, R14, R19, R24, R29, R34, R39, R44: 33K,1%; 0603@1
R5, R10, R15, R20, R25, R30, R35, R40, R45, R60, R61, R62, R63: 10k; 0603
R46, R47, R48, R49, R50, R51, R52, R53: 100; 0603
R54, R55, R56, R58: 1k; 0603
R57: 47k; 0603
R64: 5.25k; RES_0805
U$1, U$2, U$4, U$49: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$3, U$5, U$6: PZT3906; SOT_223
U$7, U$8, U$9: DSM7T; 7-SEGMENT_SMD
U$10: PIC16F676
U$11: 4.7UH_INDUCTOR
VR1: 10k; TRIMPOT-SMD-TC33X

Connections:
5V_GND: 3.3V_BUCK.5 (GND), C21.2, C23.2, C24.2, D11.A, R58.1, R61.1, R62.1, R63.1, U$10.14
5V_PWR: C21.1, R64.2, U$3.E, U$5.E, U$6.E, U$10.1, U$11.P$2
A_CNTL: R46.1, U$10.10
BAT_24V_6A: 3.3V_BUCK.7 (VIN), C23.1, R60.2
BUCK_ENABLE: 3.3V_BUCK.2 (EN), R60.1, R61.2
B_CNTL: R47.1, U$10.7
C_CNTL: R48.1, U$10.5
D_CNTL: R49.1, U$10.6
E_CNTL: R50.1, U$10.8
F_CNTL: R51.1, U$10.9
GND: C17.-, C19.2, D9.-, D9.NOT_USE, D10.A, LMP9.IN-, MOS9.SOURCE, PWR_IN.- (GND), PWR_OUT.- (GND), R43.1, VR1.2 (WIPER), VR1.3 (CCW)
G_CNTL: R52.1, U$10.2
unnamed: R46.2, U$7.7 (A-7), U$8.7 (A-7), U$9.7 (A-7)
unnamed: MOS1.DRAIN, R1.P$1 (1)
unnamed: C2.2, LMP1.OUT, MOS1.GATE
unnamed: C1.-, C3.+, D1.-, D1.NOT_USE, LMP1.IN-, LMP2.IN+, MOS1.SOURCE, R3.1, R6.P$2 (2), R7.2, R9.1
unnamed: LMP1.V+, R2.1, R3.2
unnamed: C2.1, LMP1.V-, R5.2
unnamed: D1.+, R4.2, R5.1
unnamed: C19.1, D10.C, R57.2, U$10.3, VR1.1 (CW)
unnamed: MOS2.DRAIN, R6.P$1 (1)
unnamed: C4.2, LMP2.OUT, MOS2.GATE
unnamed: C3.-, C5.+, D2.-, D2.NOT_USE, LMP2.IN-, LMP3.IN+, MOS2.SOURCE, R8.1, R11.P$2 (2), R12.2, R14.1
unnamed: LMP2.V+, R7.1, R8.2
unnamed: C4.1, LMP2.V-, R10.2
unnamed: D2.+, R9.2, R10.1
unnamed: R47.2, U$7.6 (B-6), U$8.6 (B-6), U$9.6 (B-6)
unnamed: MOS3.DRAIN, R11.P$1 (1)
unnamed: C6.2, LMP3.OUT, MOS3.GATE
unnamed: C5.-, C7.+, D3.-, D3.NOT_USE, LMP3.IN-, LMP4.IN+, MOS3.SOURCE, R13.1, R16.P$2 (2), R17.2, R19.1
unnamed: LMP3.V+, R12.1, R13.2
unnamed: C6.1, LMP3.V-, R15.2
unnamed: D3.+, R14.2, R15.1
unnamed: R56.2, U$10.11
unnamed: MOS4.DRAIN, R16.P$1 (1)
unnamed: C8.2, LMP4.OUT, MOS4.GATE
unnamed: C7.-, C9.+, D4.-, D4.NOT_USE, LMP4.IN-, LMP5.IN+, MOS4.SOURCE, R18.1, R21.P$2 (2), R22.2, R24.1
unnamed: LMP4.V+, R17.1, R18.2
unnamed: C8.1, LMP4.V-, R20.2
unnamed: D4.+, R19.2, R20.1
unnamed: R48.2, U$7.4 (C-4), U$8.4 (C-4), U$9.4 (C-4)
unnamed: MOS5.DRAIN, R21.P$1 (1)
unnamed: C10.2, LMP5.OUT, MOS5.GATE
unnamed: C9.-, C11.+, D5.-, D5.NOT_USE, LMP5.IN-, LMP6.IN+, MOS5.SOURCE, R23.1, R26.P$2 (2), R27.2, R29.1
unnamed: LMP5.V+, R22.1, R23.2
unnamed: C10.1, LMP5.V-, R25.2
unnamed: D5.+, R24.2, R25.1
unnamed: R49.2, U$7.2 (D-2), U$8.2 (D-2), U$9.2 (D-2)
unnamed: MOS6.DRAIN, R26.P$1 (1)
unnamed: C12.2, LMP6.OUT, MOS6.GATE
unnamed: C11.-, C13.+, D6.-, D6.NOT_USE, LMP6.IN-, LMP7.IN+, MOS6.SOURCE, R28.1, R31.P$2 (2), R32.2, R34.1
unnamed: LMP6.V+, R27.1, R28.2
unnamed: C12.1, LMP6.V-, R30.2
unnamed: D6.+, R29.2, R30.1
unnamed: R50.2, U$7.1 (E-1), U$8.1 (E-1), U$9.1 (E-1)
unnamed: MOS7.DRAIN, R31.P$1 (1)
unnamed: C14.2, LMP7.OUT, MOS7.GATE
unnamed: C13.-, C15.+, D7.-, D7.NOT_USE, LMP7.IN-, LMP8.IN+, MOS7.SOURCE, R33.1, R36.P$2 (2), R37.2, R39.1
unnamed: LMP7.V+, R32.1, R33.2
unnamed: C14.1, LMP7.V-, R35.2
unnamed: D7.+, R34.2, R35.1
unnamed: R56.1, U$6.B
unnamed: MOS8.DRAIN, R36.P$1 (1)
unnamed: C16.2, LMP8.OUT, MOS8.GATE
unnamed: C15.-, C17.+, D8.-, D8.NOT_USE, LMP8.IN-, LMP9.IN+, MOS8.SOURCE, R38.1, R41.P$2 (2), R42.2, R44.1
unnamed: LMP8.V+, R37.1, R38.2
unnamed: C16.1, LMP8.V-, R40.2
unnamed: D8.+, R39.2, R40.1
unnamed: U$3.C, U$3.C2 (C), U$7.3 (G1-3), U$7.8 (G2-8)
unnamed: MOS9.DRAIN, R41.P$1 (1)
unnamed: C18.2, LMP9.OUT, MOS9.GATE
unnamed: U$5.C, U$5.C2 (C), U$9.3 (G1-3), U$9.8 (G2-8)
unnamed: LMP9.V+, R42.1, R43.2
unnamed: C18.1, LMP9.V-, R45.2
unnamed: D9.+, R44.2, R45.1
unnamed: U$6.C, U$6.C2 (C), U$8.3 (G1-3), U$8.8 (G2-8)
unnamed: R55.2, U$5.B
unnamed: R54.1, U$3.B
unnamed: R53.1, U$9.5 (DP-5)
unnamed: R53.2, R55.1, U$10.13
unnamed: R54.2, U$10.12
unnamed: R51.2, U$7.9 (F-9), U$8.9 (F-9), U$9.9 (F-9)
unnamed: R52.2, U$7.10 (G-10), U$8.10 (G-10), U$9.10 (G-10)
unnamed: 3.3V_BUCK.1 (SW), C20.2, D11.C, U$11.P$1
unnamed: 3.3V_BUCK.4 (FB), R58.2, R64.1
unnamed: 3.3V_BUCK.8 (BST), C20.1
unnamed: 3.3V_BUCK.6 (FREQ), R62.2
unnamed: 3.3V_BUCK.3 (COMP), C22.1, C24.1
unnamed: C22.2, R63.2
VIN: C1.+, LMP1.IN+, PWR_IN.+ (VCC), PWR_OUT.+ (VCC), R1.P$2 (2), R2.2, R4.1, R57.1

Board: 2 copper layers, 140.6 x 63.5 mm, 132 parts (0 on the bottom side), 90 nets.
