# Repository RoboMaster-Club/Electrical-System (continued)

## EAGLE design Super_Capactior_V3.0/SuperCapacitor Schmatic V2.brd

Parts:
3.3V_BUCK: SOIC8E; SOIC127P600X170-9N
C1, C3, C5, C7, C9, C11, C13, C15, C17: 2.7V 60F; 2.7V_60F
C2, C4, C6, C8, C10, C12, C14, C16, C18: 100pF; 0603
C19, C20, C21, C22, C23: 0.1uF; 0603
C24: 0.22uF; 0603
C25: 1nF; 0603
CHARGE: XT60
D1, D2: BAL; LED-0603
D3, D4, D5, D6, D7, D8, D9: RED; LED-0603
D10: 5.1V; SOD-323
D11: 3A/40V/500mV; SMA-DIODE
MTR: XT60
R1, R12, R18, R24, R30, R36, R42, R48, R54, R63, R64, R65, R67: 1k; 0603
R2, R6, R13, R19, R25, R31, R37, R43, R49: 75k; 0603@1
R3, R7, R14, R20, R26, R32, R38, R44, R50: 61.9k; 0603@1
R4, R8, R15, R21, R27, R33, R39, R45, R51: 33K,1%; 0603@1
R5, R9, R16, R22, R28, R34, R40, R46, R52, R68, R69, R70, R71: 10k; 0603
R10, R11, R17, R23, R29, R35, R41, R47, R53: 0.05; 2512
R55, R56, R57, R58, R59, R60, R61, R62: 100; 0603
R66: 47k; 0603
R72: 5.25k; RES_0805
U$1, U$4, U$7, U$10, U$13, U$16, U$19, U$22, U$25: LMP2231; LMP2231_SOT23_5
U$2, U$5, U$8, U$11, U$14, U$17, U$20, U$23, U$26: LM385; LM385_SOT23
U$3, U$6, U$9, U$12, U$15, U$18, U$21, U$24, U$27: PMV30UN_MOS; PMV30UN_SOT23
U$28, U$29, U$34: PZT3906; SOT_223
U$30, U$31, U$32, U$33: M5
U$35, U$36, U$37: DSM7T; 7-SEGMENT_SMD
U$38: PIC16F676
U$39: 4.7UH_INDUCTOR
VR1: 10k; TRIMPOT-SMD-TC33X

Connections:
1: R17.P$1 (1), U$9.DRAIN
5V_PWR: C21.1, R72.2, U$28.E, U$29.E, U$34.E, U$38.1, U$39.P$2
ALT_GND: 3.3V_BUCK.5 (GND), C21.2, C23.2, C24.2, C25.2, D11.A, R67.1, R69.1, R70.1, R71.1, U$38.14
A_CNTL: R55.1, U$38.10
BUCK_ENABLE: 3.3V_BUCK.2 (EN), R68.1, R69.2
B_CNTL: R56.1, U$38.7
C_CNTL: R57.1, U$38.5
D_CNTL: R58.1, U$38.6
E_CNTL: R59.1, U$38.8
F_CNTL: R60.1, U$38.9
GND: C3.-, C19.2, C25.1, CHARGE.2 (GND), D1.C, D10.A, MTR.2 (GND), R7.1, U$4.IN-, U$5.-, U$5.FB, U$6.SOURCE, VR1.2 (WIPER), VR1.3 (CCW)
G_CNTL: R61.1, U$38.2
unnamed: D1.A, R1.1
unnamed: U$29.C, U$29.C2 (C), U$37.3 (G1-3), U$37.8 (G2-8)
unnamed: C2.2, R12.2, U$1.OUT, U$3.GATE
unnamed: C1.-, C3.+, D2.C, R3.1, R6.2, R8.1, R10.P$2 (2), U$1.IN-, U$2.-, U$2.FB, U$3.SOURCE, U$4.IN+
unnamed: R2.1, R3.2, U$1.V+
unnamed: C2.1, R5.2, U$1.V-
unnamed: R4.2, R5.1, U$2.+
unnamed: U$34.C, U$34.C2 (C), U$36.3 (G1-3), U$36.8 (G2-8)
unnamed: C4.2, R1.2, U$4.OUT, U$6.GATE
unnamed: R65.1, U$34.B
unnamed: R6.1, R7.2, U$4.V+
unnamed: C4.1, R9.2, U$4.V-
unnamed: R8.2, R9.1, U$5.+
unnamed: R10.P$1 (1), U$6.DRAIN
unnamed: R11.P$1 (1), U$3.DRAIN
unnamed: D2.A, R12.1
unnamed: R63.1, U$28.B
unnamed: C6.2, R18.2, U$7.OUT, U$9.GATE
unnamed: C1.+, C5.-, D3.C, R2.2, R4.1, R11.P$2 (2), R14.1, U$1.IN+, U$7.IN-, U$8.-, U$8.FB, U$9.SOURCE
unnamed: R13.1, R14.2, U$7.V+
unnamed: C6.1, R16.2, U$7.V-
unnamed: R15.2, R16.1, U$8.+
unnamed: R62.1, U$37.5 (DP-5)
unnamed: D3.A, R18.1
unnamed: R62.2, R64.1, U$38.13
unnamed: C8.2, R24.2, U$10.OUT, U$12.GATE
unnamed: C5.+, C7.-, D4.C, R13.2, R15.1, R17.P$2 (2), R20.1, U$7.IN+, U$10.IN-, U$11.-, U$11.FB, U$12.SOURCE
unnamed: R19.1, R20.2, U$10.V+
unnamed: C8.1, R22.2, U$10.V-
unnamed: R21.2, R22.1, U$11.+
unnamed: R23.P$1 (1), U$12.DRAIN
unnamed: D4.A, R24.1
unnamed: R63.2, U$38.12
unnamed: C10.2, R30.2, U$13.OUT, U$15.GATE
unnamed: C7.+, C9.-, D5.C, R19.2, R21.1, R23.P$2 (2), R26.1, U$10.IN+, U$13.IN-, U$14.-, U$14.FB, U$15.SOURCE
unnamed: R25.1, R26.2, U$13.V+
unnamed: C10.1, R28.2, U$13.V-
unnamed: R27.2, R28.1, U$14.+
unnamed: R29.P$1 (1), U$15.DRAIN
unnamed: D5.A, R30.1
unnamed: C19.1, D10.C, R66.2, U$38.3, VR1.1 (CW)
unnamed: C12.2, R36.2, U$16.OUT, U$18.GATE
unnamed: C9.+, C11.-, D6.C, R25.2, R27.1, R29.P$2 (2), R32.1, U$13.IN+, U$16.IN-, U$17.-, U$17.FB, U$18.SOURCE
unnamed: R31.1, R32.2, U$16.V+
unnamed: C12.1, R34.2, U$16.V-
unnamed: R33.2, R34.1, U$17.+
unnamed: R35.P$1 (1), U$18.DRAIN
unnamed: D6.A, R36.1
unnamed: R65.2, U$38.11
unnamed: C14.2, R42.2, U$19.OUT, U$21.GATE
unnamed: C11.+, C13.-, D7.C, R31.2, R33.1, R35.P$2 (2), R38.1, U$16.IN+, U$19.IN-, U$20.-, U$20.FB, U$21.SOURCE
unnamed: R37.1, R38.2, U$19.V+
unnamed: C14.1, R40.2, U$19.V-
unnamed: R39.2, R40.1, U$20.+
unnamed: R41.P$1 (1), U$21.DRAIN
unnamed: D7.A, R42.1
unnamed: U$28.C, U$28.C2 (C), U$35.3 (G1-3), U$35.8 (G2-8)
unnamed: C16.2, R48.2, U$22.OUT, U$24.GATE
unnamed: C13.+, C15.-, D8.C, R37.2, R39.1, R41.P$2 (2), R44.1, U$19.IN+, U$22.IN-, U$23.-, U$23.FB, U$24.SOURCE
unnamed: R43.1, R44.2, U$22.V+
unnamed: C16.1, R46.2, U$22.V-
unnamed: R45.2, R46.1, U$23.+
unnamed: R47.P$1 (1), U$24.DRAIN
unnamed: D8.A, R48.1
unnamed: R64.2, U$29.B
unnamed: C18.2, R54.2, U$25.OUT, U$27.GATE
unnamed: C15.+, C17.-, D9.C, R43.2, R45.1, R47.P$2 (2), R50.1, U$22.IN+, U$25.IN-, U$26.-, U$26.FB, U$27.SOURCE
unnamed: R49.1, R50.2, U$25.V+
unnamed: C18.1, R52.2, U$25.V-
unnamed: R51.2, R52.1, U$26.+
unnamed: R53.P$1 (1), U$27.DRAIN
unnamed: D9.A, R54.1
unnamed: R55.2, U$35.7 (A-7), U$36.7 (A-7), U$37.7 (A-7)
unnamed: R56.2, U$35.6 (B-6), U$36.6 (B-6), U$37.6 (B-6)
unnamed: R57.2, U$35.4 (C-4), U$36.4 (C-4), U$37.4 (C-4)
unnamed: R58.2, U$35.2 (D-2), U$36.2 (D-2), U$37.2 (D-2)
unnamed: R59.2, U$35.1 (E-1), U$36.1 (E-1), U$37.1 (E-1)
unnamed: R60.2, U$35.9 (F-9), U$36.9 (F-9), U$37.9 (F-9)
unnamed: R61.2, U$35.10 (G-10), U$36.10 (G-10), U$37.10 (G-10)
unnamed: 3.3V_BUCK.4 (FB), R67.2, R72.1
unnamed: 3.3V_BUCK.8 (BST), C20.1
unnamed: 3.3V_BUCK.6 (FREQ), R70.2
unnamed: 3.3V_BUCK.3 (COMP), C22.1, C24.1
unnamed: C22.2, R71.2
SW: 3.3V_BUCK.1 (SW), C20.2, D11.C, U$39.P$1
VCC: 3.3V_BUCK.7 (VIN), C17.+, C23.1, CHARGE.1 (VCC), MTR.1 (VCC), R49.2, R51.1, R53.P$2 (2), R66.1, R68.2, U$25.IN+

Board: 2 copper layers, 153.7 x 50.5 mm, 151 parts (9 on the bottom side), 98 nets.

## EAGLE design Heads-Up-Display-ToF/OledBoardV3/OledBoardV3.brd

File Heads-Up-Display-ToF/README.md:

# Sensor-Integration

This is the repository for sensor integration on the standard robot and engineer robot

## Overview

The goals of this project are:
1. Use 4 ToF sensors to detect if any walls are close to the robot
2. Display if any walls are close to the HUD
3. Use limit switches on the engineer robot to detect if an object has been grabbed
4. Make a new mount for the HUD
5. Modify or select a new HUD to make it smaller / better

## Contributors

* Henry Silva (PCB Design & Code)
* Dansen Wang (CAD & Mounting)

## Updates

### Update 8 (11/9)

#### Ammo Sensor

Ammo sensor uses laser diode and photo detector to determine if ammo in the hopper is low. PCB is a ring that is placed in the hopper with diode mounted on seperate board.

### Update 7 (11/1)

#### HUD

Added low ammo indicator. Represented by four dots in the center of the screen. Wall indicator updates made faster by reducing the number of sensor readings to take the average of and by alternating pixels on the display.

#### Control Board

Finished soldering prototype, testing and final changes will be made this week.

### Update 6 (10/26)

#### ToF Code

New method for clearing the screen fixed problem of long pause in program. Wall indicators made thinner to make room for other indicators.

Under current refresh rate, hud updates can be made faster depending on the number of times to read the tof sensor. Tests concluded that 3 tof readings before taking the average is fastest while not having false positives.

The left and right tof sensors on the front and back of the robot now have different indicators for walls to give driver a better understanding of where the walls are.

Indicators added at startup to show when the hud is ready.

Demo

### Update 5 (10/19)

#### HUD Mount

A camera holder and a bracket for the OLED screen was CADDed.
Camera Mount

Bracket for OLED was first 3D printed out with multiple slots signifying different distance the OLED screen is from the camera.

Test

With further testing, the ideal distance between the camera lens and the OLED screen is 0.35 inches. Modifications were made, and the OLED bracket was modified

Mount

Demo of the camera and OLED

Demo

A case to hold the photogate sensors was CADDed out as well. It's a simple plastic case with very low tolerance around the dimensions of the sensors. The case will then be glued onto the body of the robot.

Sensor Casing

#### OLED Control Board

Final update to the pcb. Changed button to a smaller one. XT30 for power was added. Boost was improved by adding polygons and vias. Switched from micro-USB to USB-C.

Schematic

Board

### Update 4 (10/12)

#### Wall Detection

Tested final code on breadboard. Code mostly worked, but is running slowly. I think it is because of the OLED screen and the time it takes
to clear the screen. Solution is to only update the screen when necessary (keep track of what the OLED is already displaying and only update when needed)

#### OLED Control Board

Finished schematic for control board. Added USB to serial converter with the ch340 chip, reset button for the atmega, 3 pin JST connector for the ammo sensor, and micro usb connector for programming the atmega.
Decided on placement of components on board.

Schematic

Board

### Update 3 (10/7)

#### HUD Mount

A exact replica of the plate gap in front of the camera, with a holder in the middle to hold the camera, simulating camera placement.

Mark 1 of the OLED holder, without mirror focal length calculation and OLED size on overall camera FOV consideration

Mirror Drawing

#### Wall Detection

Finished first version of code to show close walls on the HUD. Uses timed interrput to get sensor measurements every 4 milliseconds and update the OLED every 20 milliseconds. Average of sensor values in between OLED refreshes is used to determine close walls.
Currently untested, but will test before the next update. Planning to have the direction of the close wall be relative to the current
angle of the gimbal.

#### OLED Control Board

I chose the ATMEGA328p-au as the microcontrller. The board will have one connector for the OLED and 2 4-pin JST connectors for communication 
between the DJI control board and programming the microcontroller. No mounting holes have been added.

Schematic

Board

### Update 2 (9/28)

Made first schematic for smaller OLED breakout board. Removed all SPI related components and pins. Removed options.

SchematicV1

Two concept drawings for the HUD element giving the driver the information about close walls. Concept 1 takes up less space and is easier for the driver to see at glance. Concept 2 is more specific, but it is up to the drivers.

Concept 1

Concept 2

### Update 1 (9/21)

#### HUD Mount

Mating Example

Part

Concept

#### ToF Integration

Got sensors to output values of 2 ToF sensors(should work for 4). Determined a measurement of 300mm to be a wall that is "close". 

Serial Output

Model of Wall Detection

Sample Output

Researched interrupt for VL53L0X sensor. Tried what might of been the interrupt pin on the current breakout board and it did not work.

Pinout

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; 0603
C7, C8, C24: 100nF; C0603
C25, C26: 1uF; C0603
D1: GREEN; LED-0603
D2: 1A/23V/620mV; SOD-323
D12, D13: Yellow; LED-0603
IC2: FT232RL; SSOP28-LD
L1: 4.7µH/±30%/1.2A; INDUCTOR_4.7UH
P2: 0475890001; MOLEX_0475890001
R1: 47k; 0603
R2: 1k; 0603
R3: 5.6k; 0603
R4: 100k; 0603
R5, R6, R25, R26, R27, R28: 1K; R0603
R29, R30: 10K; R0603
SV1: MA03-2
U1: AP3012; SOT23-5
U2: UG-2856KLBAG01_4WSPI; FPC05024-42201
U9: ATMEGA328P_TQFP; TQFP32-08
U$1, U$2, U$3, U$4: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$5, U$8: SM03B-GHS-TB
U$6: SS1P3L-M3/84A
U$9: XT30PW-M; XT30
U$16: CSTNE16M0VH3C000R0
U$17: KSR223GLFG

Connections:
3.3V: C1.1, C2.1, D1.A, IC2.17 (3V3OUT), L1.P$1 (1), U1.4 (!SHDN!), U1.5 (VIN), U2.P$5 (VDD), U2.P$6 (BS1)
12V: C3.1, C4.1, C5.1, D2.C, R1.2, U2.P$23 (VCC)
AMMO1: U9.23 (PC0(ADC0)), U$5.P$3 (1)
AMMO2: U9.24 (PC1(ADC1)), U$5.P$4 (2)
D+: IC2.15 (USBDP), P2.3 (D+)
D-: IC2.16 (USBDM), P2.2 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C24.2, C25.2, C26.2, IC2.7 (GND), IC2.18 (GND), IC2.21 (GND), IC2.25 (AGND), IC2.26 (TEST), P2.5 (GND), R2.1, R3.1, R4.1, R28.1, SV1.6, U1.2 (GND), U2.P$1 (GND), U2.P$2 (VLSS), U2.P$3 (VSS), U2.P$7 (BS2), U2.P$8 (!CS), U2.P$10 (D!C!/SA0), U2.P$11 (GND), U2.P$12 (GND), U2.P$16 (GND), U2.P$17 (GND), U2.P$18 (GND), U2.P$19 (GND), U2.P$20 (GND), U2.P$24 (GND), U9.3 (GND), U9.5 (GND), U9.21 (AGND), U$5.P$5 (3), U$8.P$5 (3), U$9.P$2 (GND), U$16.2 (GND), U$17.P$1 (1)
MISO: SV1.1, U9.16 (PB4(MISO))
MOSI: SV1.4, U9.15 (PB3(MOSI/OC2))
unnamed: D1.C, R2.2
unnamed: R1.1, R3.2, U1.3 (FB)
unnamed: C6.1, U2.P$22 (VCOMH)
unnamed: D2.A, L1.P$2 (2), U1.1 (SW)
unnamed: R4.2, U2.P$21 (IREF)
unnamed: C7.1, IC2.2 (!DTR)
unnamed: IC2.23 (!TXLED), R6.2
unnamed: IC2.22 (!RXLED), R5.2
unnamed: D13.C, R6.1
unnamed: D12.C, R5.1
unnamed: U9.7 (PB6(XTAL1/TOSC1)), U$16.1 (IN)
unnamed: U9.8 (PB7(XTAL2/TOSC2)), U$16.3 (OUT)
unnamed: C24.1, U9.20 (AREF)
unnamed: R27.2, U9.31 (PD1(TXD))
unnamed: R26.2, U9.30 (PD0(RXD))
RESET: C7.2, R25.1, SV1.5, U9.29 (PC6(/RESET)), U$17.P$2 (2)
RX: IC2.1 (TXD), R26.1, U$8.P$3 (1)
SCK: R28.2, SV1.3, U9.17 (PB5(SCK))
SCL: R30.2, U2.P$13 (SCLK/SCL), U9.28 (PC5(ADC5/SCL))
SDA: R29.2, U2.P$14 (SDIN/SDA), U2.P$15 (NC/D2), U9.27 (PC4(ADC4/SDA))
TX: IC2.5 (RXD), R27.1, U$8.P$4 (2)
VCC: C25.1, C26.1, D12.A, D13.A, IC2.4 (VCCIO), IC2.20 (VCC), R25.2, R29.1, R30.1, SV1.2, U9.4 (VCC), U9.6 (VCC), U9.18 (AVCC), U$6.P$1 (C), U$9.P$1 (VCC)
VUSB: C8.1, P2.1 (VCC), U$6.P$2 (A)

Notes on the sheet:
Boost 3.3v -> 12v
OLED
Connectors
Atmega
USB To Serial
USB

Board: 2 copper layers, 56.6 x 33.3 mm, 44 parts (0 on the bottom side), 32 nets.

## EAGLE design Low-Ammo Detector/RingBoard/hopperBoard.brd

Board: 2 copper layers, 171.9 x 172.0 mm, 17 parts (0 on the bottom side), 7 nets.

Parts:
C1: 4.7uF; C0603
C2: 22pF; C0603
C3: 10uF; C0603
R1: 330k; R0603
R2: 180k; R0603
U$1, U$2: 2PIN
U$3, U$4: OPL550
U$5: TPS62260
U$6: SM02B-GHS-TB
U$7, U$10, U$11, U$12: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN
U$8: SM03B-GHS-TB
U$9: 2.2uH; 74479776222

Connections:
1.5V: C2.1, C3.1, R1.2, U$1.P$2, U$2.P$2, U$9.P$2
5V: C1.1, U$3.P$3, U$4.P$3, U$5.P$1, U$5.P$3, U$6.P$3
AMMO1: U$4.P$2, U$8.P$4
AMMO2: U$3.P$2, U$8.P$3
GND: C1.2, C3.2, R2.1, U$1.P$1, U$2.P$1, U$3.P$1, U$4.P$1, U$5.P$2, U$6.P$4, U$8.P$5
unnamed: U$5.P$5, U$9.P$1
unnamed: C2.2, R1.1, R2.2, U$5.P$4

## Commit log

2019-01-28 Create Voltage Regulator Code
2019-02-02 Update project structure && README file
2019-02-02 Update folder structure and README
2019-02-02 initial upload
2019-02-08 Temperature Sensor
    This is the temperature sensor with the measured results displayed on LCD.
2019-02-08 Add files via upload
    This is the code for testing
2019-02-09 added img
2019-02-16 Combine Voltage Regulater2
2019-02-16 Description for volRegulator
2019-02-16 TempSensor Guide
2019-02-22 schematic_2/2019
    The voltage regulator needs to be changed.
    LCD and I2C need to be added
2019-02-23 Sample code from Adafruit
2019-02-28 Electrical System Diagram
2019-03-02 Create server
2019-03-02 Add files via upload
    the voltage regulator will be changed later.
2019-03-08 This is PCB design for buck converter circuit.
2019-03-16 include 3 files in global
2019-03-23 Create Combined_UART.ino
    From Arduino board to HUD system. Displaying Vbat, Vcap, Temp..
2019-03-23 Create Web Browser
2019-03-25 Unzip buck converter design
2019-03-25 Remove buck circuit zip file from github
2019-03-30 working code
2019-03-30 platformIO project
2019-03-30 index on charBranch: e3ba9fe platformIO project
2019-04-02 Finished basic http server, websocket handler, basic web interface
2019-04-10 Set websocket to broad every connected device
2019-04-10 Reorganize project folder
2019-04-10 Move all content to embeddedSystem folder
2019-04-11 Test oledmonitor lib
2019-04-13 Finish sd logger wrapper class and python decoder
2019-04-13 Integrate logger and oled to main executive
2019-04-14 Integrate PDP measurement
2019-04-14 Remove files
2019-04-27 Rearrange development structure
2019-04-27 Rearrange project folder
2019-05-04 Add files via upload
    my shit
2019-05-20 Add time of flight sensor manager
2019-05-21 Add startup sound
2019-05-21 Update web interface; finish digital control via MCP23008
2019-07-18 added some circuit and updated old ones
2019-09-14 README.md
    Project progress update
2019-09-14 Create README.md
    Constant updating the project progress
2019-09-14 update from Kevin's Local Files
2019-09-14 Added Fun.txt
2019-09-14 removed fun.txt
2019-09-14 rename a bunch of stuff
2019-09-28 changed electrical diagram
2019-11-10 updated all power distribution board
2019-11-10 re-orginize our folder structure
2019-11-10 added changes since repo changes
2019-11-10 changed new system diagram
2019-11-10 readme updated
2019-11-11 readme changes
2019-11-11 added gitignore for bash script
2019-11-11 updated the readme
2019-11-14 added changes that were left behind
2019-12-07 Ammo Board V2
2019-12-31 ready
2020-01-06 added project
2020-01-08 test board update
2020-01-25 OLED board update
2020-01-26 added notes
2020-02-11 fixed mistake by ben, approved for manufacturing
2020-03-01 Kevin fixed the v4 controller board! Please review it carefully
2020-03-05 fixed batt power and usb-c power conflict in the Draft Folder
2020-03-05 deleted the temp file
2020-03-06 Thursday Meeting changes to the brd, waiting for final submit
2020-03-07 almost done kevin
2020-03-07 Add files via upload
    Current incomplete parts list for new board
2020-03-07 Updated Schematic
2020-03-08 final -kevin
2020-03-08 3d file uploaded
2020-03-08 added multiplexer board
2020-03-08 Create readme.md
    Siyu created the first version of readme file
2020-03-10 Update readme.md
    Siyu updates I2C Address
